# Keil uVision project moban.uvprojx, settings and files
target environment (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: moban +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\libraries\inc;.\libraries\src;.\startup;.\app\AS62;.\app\FLASH;.\app\Max485;.\app\PM;.\app\TemHem;.\HARDWARE\BEEP;.\HARDWARE\KEY;.\HARDWARE\LED;.\HARDWARE\RTC;.\HARDWARE\SPI;.\HARDWARE\TIMER;.\system\delay;.\system\sys;.\system\usart;.\system\usart_485;.\system\usart_PM;.\HARDWARE\EXIT;.\app\DATA;.\app\LCDFLASH;.\modbus\check;.\modbus\conmunication;.\HARDWARE\TIMER;.\modbus\Modbus_tra;.\app\TVOC;.\HARDWARE\CONTR;.\HARDWARE\REMOTE;.\app\CRC;.\app\CMD;.\HARDWARE\STMFLASH;.\system;.\HARDWARE\HMI;.\HARDWARE\UART_485;.\HARDWARE\WDG
  memory RVCT4: ROM 0x8002800 size 0xd800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c system_init.c
  group system
    ./system/delay/: delay.c
    ./system/sys/: sys.c
    ./system/usart/: usart.c
    ./system/: config.c
  group app
    ./app/AS62/: drv_AS62.c
    ./app/CRC/: crc8_16.c
    ./app/CMD/: cmd.c cmd1.c
  group startup
    ./startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group libraries
    ./libraries/src/: stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_bkp.c misc.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_iwdg.c
  group HARDWARE
    ./HARDWARE/CONTR/: control.c
    ./HARDWARE/REMOTE/: remote.c receive.c
    ./HARDWARE/STMFLASH/: stmflash.c
    ./HARDWARE/HMI/: hmi_usart.c
    ./HARDWARE/UART_485/: uart_485.c
    ./HARDWARE/WDG/: wdg.c
  group ReadMe
    ./: ReadMe.txt
